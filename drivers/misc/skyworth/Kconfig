## drivers/misc/skyworth/Kconfig
```kconfig
config LED_CONTROL
        tristate "led debug tools"
        help
                gpio debug tools
```
